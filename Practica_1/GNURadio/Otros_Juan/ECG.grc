options:
  parameters:
    author: juan
    generate_options: qt_gui
    id: ECG
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: M
  id: variable
  parameters:
    value: '3'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '360'
  states: {}
- name: samp_rate_1
  id: variable
  parameters:
    value: '360'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/juan/Descargas/ecg_100.bin
    repeat: 'True'
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate_1
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    M: M
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.decim_block):   # <-- CORRECCIÓN: era gr.sync_decimator
          def __init__(self, M=64):
              gr.decim_block.__init__(   # <-- también aquí
                  self,
                  name='Promedios_de_tiempos',
                  in_sig=[np.float32],
                  out_sig=[np.float32],
                  decim=M
              )
              self.M = M

          def work(self, input_items, output_items):
              x = input_items[0]
              y0 = output_items[0]
              n_out = len(y0)

              for i in range(n_out):
                  acum_x = 0.0
                  Ntotales = 0

                  ventana = x[i*self.M : (i+1)*self.M]

                  Ntotales += len(ventana)
                  acum_x += np.sum(ventana)

                  media = acum_x / Ntotales
                  y0[i] = media

              return n_out
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    size: '342'
    srate: samp_rate/M
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', epy_block_0, '0']
- [blocks_throttle2_0, '0', qtgui_time_sink_x_0_0, '0']
- [epy_block_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
