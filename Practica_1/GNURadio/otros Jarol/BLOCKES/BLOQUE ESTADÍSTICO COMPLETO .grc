options:
  parameters:
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '360'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0.1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\molan\Downloads\BASURAA\ecg_118.bin
    repeat: 'True'
    type: float
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '15'
    max_iter: '4000'
    scale: '0.1'
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\n\nclass blk(gr.sync_block):\n    def __init__(self):\n        gr.sync_block.__init__(\n            self,\n            name='Promedios_de_tiempos',\n            in_sig=[np.float32],\n            out_sig=[np.float32, np.float32, np.float32, np.float32, np.float32]\n        )\n        # Variables de estado persistentes\n        self.acum_x = 0.0\n        self.acum_x2 = 0.0\n        self.Ntotales = 0\n\n    def work(self, input_items, output_items):\n        x = input_items[0]       # Señal de entrada\n        y0 = output_items[0]     # Promedio acumulado (Media)\n        y1 = output_items[1]     # Media cuadrática (MS)\n        y2 = output_items[2]     # RMS\n        y3 = output_items[3]     # Potencia promedio\n        y4 = output_items[4]     # Desviación estándar (Std)\n        \n        N = len(x)\n        if N == 0:\n            return 0\n            \n        # 1. Actualizar el contador global de muestras\n        self.Ntotales += N\n        \n        # 2. Acumulación histórica lineal y cuadrática\n        self.acum_x += np.sum(x)\n        self.acum_x2 += np.sum(x**2)\n        \n        # 3. Cálculo de estimadores temporales globales\n        media_global = self.acum_x / self.Ntotales\n        ms_global = self.acum_x2 / self.Ntotales      # Media de los cuadrados\n        rms_global = np.sqrt(ms_global)\n        \n        # 4. Varianza = E[X^2] - (E[X])^2\n        varianza = ms_global - (media_global**2)\n        if varianza < 0: \n            varianza = 0  # Evita errores numéricos de precisión por flotantes\n        std_global = np.sqrt(varianza)\n        \n        # 5. Asignar los valores calculados a los vectores de salida de GRC\n        y0[:] = media_global\n        y1[:] = ms_global\n        y2[:] = rms_global\n        y3[:] = ms_global  # En ingeniería, la potencia promedio de una señal es su MS\n        y4[:] = std_global\n        \n        return len(x)\n\n"
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"Media  "'
    type: float
  states: {}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"Media cuadratica"'
    type: float
  states: {}
- name: qtgui_number_sink_2
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"Rms"'
    type: float
  states: {}
- name: qtgui_number_sink_3
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"Potencia promedio "'
    type: float
  states: {}
- name: qtgui_number_sink_4
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"Desviación estándar "'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"ORIGINAL"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"SIN RUIDO"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"RUIDO"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', blocks_throttle2_0, '0']
- [blocks_file_source_0, '0', blocks_add_xx_0, '0']
- [blocks_file_source_0, '0', blocks_throttle2_0_0, '0']
- [blocks_moving_average_xx_0, '0', epy_block_2, '0']
- [blocks_moving_average_xx_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_throttle2_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_throttle2_0, '0', qtgui_time_sink_x_0_1, '0']
- [blocks_throttle2_0_0, '0', qtgui_time_sink_x_0, '0']
- [epy_block_2, '0', qtgui_number_sink_0, '0']
- [epy_block_2, '1', qtgui_number_sink_1, '0']
- [epy_block_2, '2', qtgui_number_sink_2, '0']
- [epy_block_2, '3', qtgui_number_sink_3, '0']
- [epy_block_2, '4', qtgui_number_sink_4, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
