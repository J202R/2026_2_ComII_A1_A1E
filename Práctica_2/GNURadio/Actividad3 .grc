options:
  parameters:
    author: radiogis_director
    generate_options: qt_gui
    id: prac3a
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: N
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: Rb
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: Sps
  id: variable
  parameters:
    value: len(h)
  states: {}
- name: h
  id: variable
  parameters:
    value: np.array([1,1,1,1])
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: Rb*Sps
  states: {}
- name: Menu
  id: qtgui_tab_widget
  parameters:
    label0: Time & Freq
    label1: Freq
    num_tabs: '2'
  states: {}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: '-1./2.'
    type: float
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '76'
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: N
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: '/home/juan/Escritorio/LAB #2/rana.jpg'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '2.'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '[1/(N*samp_rate)]*N'
    type: float
    vlen: N
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    N: N
    _source_code: |
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  
          """vector averager. N is the lengh of the vector"""

          def __init__(self, N=1024):
              gr.sync_block.__init__(
                  self,
                  name='e_vec_averager_ff',   
                  in_sig=[(np.float32,N)],
                  out_sig=[(np.float32,N)]
              )
              self.N = N
              self.rows_counter=0
              self.sum=0

          def work(self, input_items, output_items):
              x=input_items[0]
              y=output_items[0]
              self.sum += np.sum(x, axis=0)
              self.rows_counter += len(x)
              y[:]=self.sum/self.rows_counter
              return len(output_items[0])
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\n\nclass blk(gr.sync_block):\n    def __init__(self):\n        gr.sync_block.__init__(\n            self,\n            name='Promedios_de_tiempos',\n            in_sig=[np.float32],\n            out_sig=[np.float32, np.float32, np.float32, np.float32, np.float32]\n        )\n        # Variables de estado persistentes\n        self.acum_x = 0.0\n        self.acum_x2 = 0.0\n        self.Ntotales = 0\n\n    def work(self, input_items, output_items):\n        x = input_items[0]       # Señal de entrada\n        y0 = output_items[0]     # Promedio acumulado (Media)\n        y1 = output_items[1]     # Media cuadrática (MS)\n        y2 = output_items[2]     # RMS\n        y3 = output_items[3]     # Potencia promedio\n        y4 = output_items[4]     # Desviación estándar (Std)\n        \n        N = len(x)\n        if N == 0:\n            return 0\n            \n        # 1. Actualizar el contador global de muestras\n        self.Ntotales += N\n        \n        # 2. Acumulación histórica lineal y cuadrática\n        self.acum_x += np.sum(x)\n        self.acum_x2 += np.sum(x**2)\n        \n        # 3. Cálculo de estimadores temporales globales\n        media_global = self.acum_x / self.Ntotales\n        ms_global = self.acum_x2 / self.Ntotales      # Media de los cuadrados\n        rms_global = np.sqrt(ms_global)\n        \n        # 4. Varianza = E[X^2] - (E[X])^2\n        varianza = ms_global - (media_global**2)\n        if varianza < 0: \n            varianza = 0  # Evita errores numéricos de precisión por flotantes\n        std_global = np.sqrt(varianza)\n        \n        # 5. Asignar los valores calculados a los vectores de salida de GRC\n        y0[:] = media_global\n        y1[:] = ms_global\n        y2[:] = rms_global\n        y3[:] = ms_global  # En ingeniería, la potencia promedio de una señal es su MS\n        y4[:] = std_global\n        \n        return len(x)\n\n"
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: N
    forward: 'True'
    shift: 'True'
    type: float
    window: '[1]*N'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: Sps
    taps: h
    type: fff
  states: {}
- name: note_0
  id: note
  parameters:
    note: INSTRUMENTOS
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: N
    gui_hint: Menu@1:3,0,1,1
    type: float
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"Media"'
    type: float
  states: {}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"Desviación Estandar"'
    type: float
  states: {}
- name: qtgui_number_sink_0_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"Potencia Promedio"'
    type: float
  states: {}
- name: qtgui_number_sink_0_2
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"Media Cuadratica"'
    type: float
  states: {}
- name: qtgui_number_sink_0_3
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"RMS"'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: Menu@0:2,0,1,1
    label1: p4
    size: 16*Sps
    srate: samp_rate
    type: float
    width1: '3'
    ymax: '1.50'
    ymin: '-1.50'
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    gui_hint: Menu@0:3,0,1,1
    label1: p4
    name: '"PSD (Watts/Hz)"'
    vlen: N
    x_axis_label: '"f"'
    x_start: '-samp_rate/2'
    x_step: samp_rate/N
    x_units: '"Hz"'
    y_axis_label: '"Sx(f)"'
    y_units: '"Watss/Hz"'
    ymax: 1/Rb
    ymin: '0'
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: p3
  states: {}
- name: virtual_sink_0_1_0
  id: virtual_sink
  parameters:
    stream_id: p4
  states: {}
- name: virtual_sink_0_1_0_0
  id: virtual_sink
  parameters:
    stream_id: p5
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: p4
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: p5
  states: {}

connections:
- [analog_const_source_x_0_0, '0', blocks_add_xx_0, '0']
- [analog_noise_source_x_0, '0', virtual_sink_0_1_0_0, '0']
- [blocks_add_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_char_to_float_0, '0', blocks_add_xx_0, '1']
- [blocks_char_to_float_0, '0', virtual_sink_0_1, '0']
- [blocks_complex_to_mag_squared_0, '0', epy_block_0, '0']
- [blocks_file_source_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_multiply_const_vxx_0, '0', interp_fir_filter_xxx_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_vector_sink_f_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_throttle_0, '0', epy_block_1, '0']
- [blocks_throttle_0, '0', virtual_sink_0_1_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_char_to_float_0, '0']
- [epy_block_0, '0', blocks_multiply_const_vxx_1, '0']
- [epy_block_1, '0', qtgui_number_sink_0, '0']
- [epy_block_1, '1', qtgui_number_sink_0_2, '0']
- [epy_block_1, '2', qtgui_number_sink_0_3, '0']
- [epy_block_1, '3', qtgui_number_sink_0_1, '0']
- [epy_block_1, '4', qtgui_number_sink_0_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [interp_fir_filter_xxx_0, '0', blocks_throttle_0, '0']
- [virtual_source_0, '0', blocks_stream_to_vector_0, '0']
- [virtual_source_0, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_0, '0', qtgui_time_sink_x_0, '0']
- [virtual_source_0_0, '0', blocks_null_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
